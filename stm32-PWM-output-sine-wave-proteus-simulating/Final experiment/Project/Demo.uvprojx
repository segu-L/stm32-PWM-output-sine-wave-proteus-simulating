# Keil uVision project Demo.uvprojx, settings and files
target TemplateSTM32F4 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo.elf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_exti.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group User
    ../User/: stm32f4xx_it.c main.c
software components: CMSIS:CORE 4.1.0
